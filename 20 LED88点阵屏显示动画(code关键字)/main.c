#include <REGX52.H>
#include "MatrixLED.h"
#include "Delay.h"

//code关键字：从程序运行存储器移入程序存储器（可节省程序运行存储器空间，但在main中不再可改）
unsigned char code Animation[] = {
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0x3C,0x42,0x42,0x24,0x00,0x00,0x40,0x7E,
	0x48,0x58,0x00,0x00,0x24,0x52,0x4A,0x24,
	0x00,0x00,0x38,0x4C,0x44,0x3A,0x00,0x00,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

void main()
{
	unsigned char i, Offset = 0, Count = 0;
	MatrixLED_Init();
	while(1)
	{
		
		for(i = 0; i <= 7; i++)
		{
			MatrixLED_Show(i, Animation[i + Offset]);
		}
		
		//Count“手动延时”
		//Offset偏移
		
		Count++;
		if(Count >= 10)
		{
			Count = 0;
			Offset++;
			if(Offset > 32)
			{
				Offset = 0;
			}
		}
		
	}
}